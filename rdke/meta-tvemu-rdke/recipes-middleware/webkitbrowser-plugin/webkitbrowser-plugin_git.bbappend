# The plug-in is built with its bindings for AAMP, RDK's player for HLS and
# DASH (the recipe's default). They were left out here while AAMP did not
# build; recipes-middleware/aamp and recipes-middleware/player-interface say
# what it took. The reference user interface plays its video with them.
